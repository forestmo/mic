## drivers/infiniband/hw/scif/Kconfig
```kconfig
config INFINIBAND_SCIF
	tristate "SCIF RDMA driver support"
	depends on 64BIT && X86 && SCIF
	---help---
	  RDMA over SCIF driver.
```
